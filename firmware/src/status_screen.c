#include "status_screen.h"

#include <string.h>

/* Tiny 5x7 font for ASCII 32..90 (subset). Each glyph: 5 columns, LSB top. */
static const uint8_t FONT5X7[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, /* space */
    {0x00, 0x00, 0x5F, 0x00, 0x00}, /* ! */
    {0x00, 0x07, 0x00, 0x07, 0x00},
    {0x14, 0x7F, 0x14, 0x7F, 0x14},
    {0x24, 0x2A, 0x7F, 0x2A, 0x12},
    {0x23, 0x13, 0x08, 0x64, 0x62},
    {0x36, 0x49, 0x55, 0x22, 0x50},
    {0x00, 0x05, 0x03, 0x00, 0x00},
    {0x00, 0x1C, 0x22, 0x41, 0x00},
    {0x00, 0x41, 0x22, 0x1C, 0x00},
    {0x08, 0x2A, 0x1C, 0x2A, 0x08},
    {0x08, 0x08, 0x3E, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00},
    {0x08, 0x08, 0x08, 0x08, 0x08},
    {0x00, 0x60, 0x60, 0x00, 0x00},
    {0x20, 0x10, 0x08, 0x04, 0x02},
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* 0 */
    {0x00, 0x42, 0x7F, 0x40, 0x00},
    {0x42, 0x61, 0x51, 0x49, 0x46},
    {0x21, 0x41, 0x45, 0x4B, 0x31},
    {0x18, 0x14, 0x12, 0x7F, 0x10},
    {0x27, 0x45, 0x45, 0x45, 0x39},
    {0x3C, 0x4A, 0x49, 0x49, 0x30},
    {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36},
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 9 */
    {0x00, 0x36, 0x36, 0x00, 0x00},
    {0x00, 0x56, 0x36, 0x00, 0x00},
    {0x00, 0x08, 0x14, 0x22, 0x41},
    {0x14, 0x14, 0x14, 0x14, 0x14},
    {0x41, 0x22, 0x14, 0x08, 0x00},
    {0x02, 0x01, 0x51, 0x09, 0x06},
    {0x32, 0x49, 0x79, 0x41, 0x3E},
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* A */
    {0x7F, 0x49, 0x49, 0x49, 0x36},
    {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C},
    {0x7F, 0x49, 0x49, 0x49, 0x41},
    {0x7F, 0x09, 0x09, 0x09, 0x01},
    {0x3E, 0x41, 0x49, 0x49, 0x7A},
    {0x7F, 0x08, 0x08, 0x08, 0x7F},
    {0x00, 0x41, 0x7F, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3F, 0x01},
    {0x7F, 0x08, 0x14, 0x22, 0x41},
    {0x7F, 0x40, 0x40, 0x40, 0x40},
    {0x7F, 0x02, 0x0C, 0x02, 0x7F},
    {0x7F, 0x04, 0x08, 0x10, 0x7F},
    {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06},
    {0x3E, 0x41, 0x51, 0x21, 0x5E},
    {0x7F, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31},
    {0x01, 0x01, 0x7F, 0x01, 0x01},
    {0x3F, 0x40, 0x40, 0x40, 0x3F},
    {0x1F, 0x20, 0x40, 0x20, 0x1F},
    {0x7F, 0x20, 0x18, 0x20, 0x7F},
    {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x03, 0x04, 0x78, 0x04, 0x03},
    {0x61, 0x51, 0x49, 0x45, 0x43}, /* Z */
};

static void set_px(uint8_t *frame, int x, int y, int black)
{
    if (x < 0 || y < 0 || x >= UC8251D_WIDTH || y >= UC8251D_HEIGHT) {
        return;
    }
    int idx = y * UC8251D_WIDTH + x;
    if (black) {
        frame[idx / 8] &= (uint8_t)~(1u << (7 - (idx % 8)));
    } else {
        frame[idx / 8] |= (uint8_t)(1u << (7 - (idx % 8)));
    }
}

static void draw_char(uint8_t *frame, int x, int y, char c, int scale)
{
    if (c >= 'a' && c <= 'z') {
        c = (char)(c - 'a' + 'A');
    }
    if (c < 32 || c > 90) {
        c = '?';
    }
    const uint8_t *g = FONT5X7[c - 32];
    for (int col = 0; col < 5; col++) {
        uint8_t bits = g[col];
        for (int row = 0; row < 7; row++) {
            if (bits & (1u << row)) {
                for (int dy = 0; dy < scale; dy++) {
                    for (int dx = 0; dx < scale; dx++) {
                        set_px(frame, x + col * scale + dx, y + row * scale + dy, 1);
                    }
                }
            }
        }
    }
}

static void draw_text(uint8_t *frame, int x, int y, const char *s, int scale)
{
    if (!s) {
        return;
    }
    int cx = x;
    for (; *s; s++) {
        if (*s == '\n') {
            y += 8 * scale;
            cx = x;
            continue;
        }
        draw_char(frame, cx, y, *s, scale);
        cx += 6 * scale;
        if (cx > UC8251D_WIDTH - 6 * scale) {
            y += 8 * scale;
            cx = x;
        }
    }
}

void status_screen_clear_white(uint8_t *frame)
{
    memset(frame, 0xFF, UC8251D_BUFFER_SIZE);
}

void status_screen_message(uint8_t *frame, const char *title, const char *line2, const char *line3)
{
    status_screen_clear_white(frame);
    for (int i = 0; i < UC8251D_WIDTH; i++) {
        set_px(frame, i, 0, 1);
        set_px(frame, i, UC8251D_HEIGHT - 1, 1);
    }
    for (int i = 0; i < UC8251D_HEIGHT; i++) {
        set_px(frame, 0, i, 1);
        set_px(frame, UC8251D_WIDTH - 1, i, 1);
    }
    draw_text(frame, 6, 10, title ? title : "", 2);
    draw_text(frame, 6, 50, line2 ? line2 : "", 1);
    draw_text(frame, 6, 80, line3 ? line3 : "", 1);
    draw_text(frame, 6, 260, "USB: SET_WIFI ssid pass", 1);
}
